v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -20 -60 120 -60 {lab=#net1}
N -20 -40 120 -40 {lab=#net2}
C {comp_test.sym} -170 -50 0 0 {name=x2}
C {latch_stage_test.sym} 270 -40 0 0 {name=x1}
